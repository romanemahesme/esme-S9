DESCRIPTION = "Recipe for ESME Package Group"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS:${PN} = "esme-gpio-toggle"
